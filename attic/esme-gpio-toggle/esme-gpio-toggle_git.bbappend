inherit externalsrc
EXTERNALSRC = "/home/amelie/w/src/esme-3s11-gpio-toggle"
EXTERNALSRC_BUILD = "/home/amelie/w/src/esme-3s11-gpio-toggle"

# initial_rev .: c0ccd5cd2ccd19768312bd9c6ca07c8e4d13f930
