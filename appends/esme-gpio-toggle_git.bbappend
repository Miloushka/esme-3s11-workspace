inherit externalsrc
EXTERNALSRC = "/home/amelie/w/src/esme-3s11-gpio-toggle"
EXTERNALSRC_BUILD = "/home/amelie/w/src/esme-3s11-gpio-toggle"

# initial_rev .: bf034c102cf8f18096f00a495083a5adfb28ba5d
